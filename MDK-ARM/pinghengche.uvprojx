# Keil uVision project pinghengche.uvprojx, settings and files
target pinghengche (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: pinghengche +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\System;..\App;..\Hardware;..\Hardware\Encoder;..\Hardware\Key;..\Hardware\LED;..\Hardware\Motor;..\Hardware\MPU6050;..\Hardware\MyI2C;..\Hardware\OLED;..\Hardware\PWM;..\Hardware\Serial
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group System
    ../System/: Delay.c Timer.c
  group App
    ../App/: BlueSerial.c PID.c
  group Hardware
    ../Hardware/Encoder/: Encoder.c
    ../Hardware/Key/: Key.c
    ../Hardware/LED/: LED.c
    ../Hardware/Motor/: Motor.c
    ../Hardware/MPU6050/: MPU6050.c
    ../Hardware/MyI2C/: MyI2C.c
    ../Hardware/OLED/: OLED.c OLED_Data.c
    ../Hardware/PWM/: PWM.c
    ../Hardware/Serial/: Serial.c
software components: CMSIS:CORE 6.2.0
